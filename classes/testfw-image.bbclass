IMAGE_INSTALL:append = " \
    test-framework \
    bash \
    jq dialog \
"
